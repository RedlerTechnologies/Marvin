# IAR project TIM_PWM_Input.ewp, settings and files
configuration TIM_PWM_Input (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: C:\Projects\MarvinTester\Software\Project\; C:\Projects\MarvinTester\Software\Libraries\CMSIS\Include; C:\Projects\MarvinTester\Software\Libraries\CMSIS\ST\STM32F0xx\Include; C:\Projects\MarvinTester\Software\Libraries\STM32F0xx_StdPeriph_Driver\inc; C:\Projects\MarvinTester\Software\Utilities\STM32F0-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM_PWM_Input.hex
  ILINK.IlinkOutputFile: MARVIN_Tester.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group STM32F0-Discovery
    ../../Utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dac.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c USART.c
